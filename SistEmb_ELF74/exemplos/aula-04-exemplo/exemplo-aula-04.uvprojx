# Keil uVision project exemplo-aula-04.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exemplo-aula-04
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1294NCPDT TARGET_IS_TM4C129_RA1
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
